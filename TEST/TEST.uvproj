# Keil uVision project TEST.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM7 (Big Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI) EBIG
  output: TEST
  c flags: Optim=1 OneElfS=1 wLevel=2
  group Source Group 1
    ./: TEST.s
